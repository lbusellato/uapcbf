Commit message: Fix previous commit

File: jaka_description/urdf/jaka.urdf (robot description, URDF)
Before this commit: robot jaka_zu5, 9 links, 8 joints
Joints:
- joint fixed: origin xyz=0 0 0 rpy=0 0 0.785 -> xyz=0 0 0 rpy=0 0 0.7854
